# Keil uVision project FCMD_v.1.uvprojx, settings and files
target STM32L475 (6150000::V6.15::ARMCLANG)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FCMD_v.1 +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: ..\Commander;..\Drivers\My_Drivers;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\STM32L4xx_HAL_Driver\Inc;.\ThirdParty\FreeRTOS\include;.\ThirdParty\FreeRTOS\portable\GCC\ARM_CM4F;..\Drivers\BSP\Components\es_wifi;..\Drivers\BSP\Components\Common;..\Drivers\BSP\B-L475E-IOT01
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group app
    ./: main.c
    ../Drivers/My_Drivers/: main.h fcmd.c fcmd.h
  group rtos
    ./ThirdParty/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ./ThirdParty/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ./ThirdParty/FreeRTOS/include/: FreeRTOSConfig.h
  group my_lib
    ../Drivers/My_Drivers/: Processes.c Processes.h uart.c uart.h gpio.c gpio.h bsp.c bsp.h spi.c spi.h
  group Startup
    ./: startup_stm32l475xx.s
    ../Drivers/CMSIS/: system_stm32l4xx.c
  group HAL
    ../Drivers/My_Drivers/: stm32l4xx_hal_conf.h
    ../Drivers/STM32L4xx_HAL_Driver/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
  group WiFi
    ../Drivers/BSP/Components/es_wifi/: es_wifi_conf.h es_wifi_io.c es_wifi_io.h wifi.c wifi.h es_wifi.c es_wifi.h
  group HTS221
    ../Drivers/BSP/Components/hts221/: hts221.h
